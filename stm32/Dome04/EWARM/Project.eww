<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Dome04.ewp</path>
  </project>
  <batchBuild />
</workspace>
